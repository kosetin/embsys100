<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\..\..\..\..\MyBlinkingLED\MyBlinkingLED.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\STMCubeMx_MorseCode.ewp</path>
    </project>
    <batchBuild />
</workspace>
