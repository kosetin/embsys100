<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\..\..\assignment02\assignment02_source\assignment02.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\HelloWorld.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\..\..\..\MyBlinkingLED\MyBlinkingLED.ewp</path>
    </project>
    <batchBuild />
</workspace>
