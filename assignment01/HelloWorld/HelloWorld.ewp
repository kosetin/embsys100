# IAR project HelloWorld.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F401RE ST STM32F401RE
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 0
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; STM32F401xx
  ICCARM.CCIncludePath2: inc; common
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: HelloWorld.sim
  ILINK.IlinkOutputFile: c.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: Default None
  General.CoreVariant: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  OBJCOPY.OOCOutputFile: c.srec
  group (top)
    ../../assignment05/: div2Asm.s swapCharsAsm.s
    ../../../../Downloads/: sqrAsm.s
  group Common
    common/: misc.c startup_stm32f401xx.s stm32f4xx_gpio.c stm32f4xx_rcc.c stm32f4xx_usart.c
  group User
    src/: hw_init.c interrupt.c main.c print.c
  group User/Inc
    inc/: hw_init.h interrupt.h main.h nucleoboard.h print.h
